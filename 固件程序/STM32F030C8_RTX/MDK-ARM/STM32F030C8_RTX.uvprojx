# Keil uVision project STM32F030C8_RTX.uvprojx, settings and files
target STM32F030C8_RTX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F030C8_RTX +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8,RTX_OS_USE
  c include: ../Inc;                                    ../Drivers/STM32F0xx_HAL_Driver/Inc;                                    ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                    ../Drivers/CMSIS/Include;                                    ..\Drivers\BSP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: delay.c taskApp.c stm32f0xx_call_back.c device.c main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group RTX_Config
    ../RTX_Config/: RTX_Conf_CM.c
  group Drivers/BSP
    ../Drivers/BSP/Src/: led.c uart.c wireless_app.c wireless_drv.c stmflash.c
    ../Src/: stm32f0_spi.c
  group Application/Frame
    ../Src/: protocol.c crc16.c
  group Application/Encrypt
    ../Src/: 74.c aes.c encrypt.c rsa.c
software components: CMSIS:CORE 4.3.0
